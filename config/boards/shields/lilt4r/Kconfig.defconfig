## config/boards/shields/lilt4r/Kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config SHIELD_LILT4R
    def_bool $(shields_list_contains,lilt4r)
```
